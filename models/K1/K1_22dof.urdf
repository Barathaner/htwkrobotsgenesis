Commit message: test

File: models/K1/K1_22dof.urdf (robot description, URDF)
Before this commit: robot K1, 23 links, 22 joints
Links:
- added link world
Joints:
- added joint world_joint: type floating, parent world, child Trunk, origin xyz=0 0 0
